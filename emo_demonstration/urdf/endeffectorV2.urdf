Commit message: emo pre party implementation

File: emo_demonstration/urdf/endeffectorV2.urdf (robot description, URDF)
Before this commit: robot endeffector, 6 links, 5 joints
Joints:
- joint gripper_center: origin xyz=0.0 0.0 0.16 rpy=0 0 0 -> xyz=-0.00 0.0 0.16 rpy=0 0 0
